# Repository KarenSafaryan/Spatial_Sparrow

File README.md:

# SpatialSparrow

Multimodal rate discriminaton behavioral task for mice.

## Description of the setup

This should show a labeled picture of the setup. 

## Data saving and automatic copy

This should say what gets saved where and what is automatically copied and when. 

The TouchShaker teensy module reports lick and handle touch times, these get communicated and logged by Bpod.

### SessionData.RawEvents

Event list correspondence :

| TouchShaker byte | Event |
|------------------|-------|
| TouchShaker1_1 | left_spout_touch |
| TouchShaker1_2 | right_spout_touch |
| TouchShaker1_3 | left_spout_release |
| TouchShaker1_4 | right_spout_release |
| TouchShaker1_5 | left_handle_touch |
| TouchShaker1_6 | right_handle_touch |
| TouchShaker1_7 | both_handle_touch |
| TouchShaker1_8 | left_handle_release |
| TouchShaker1_9 | right_handle_release |
| TouchShaker1_14 | acknowledge |
| TouchShaker1_15 | error |

State list correspondence:

## Settings and description

Settings can be set from Bpod (mat files in Bpod Local/Settings).
Default settings are in SpatialSparrow.m

Settings for `training control`:

| Setting | Default | Description |
|---------|---------|-------------|
| SubjectName | | Name of the mouse |
| RewardedModality | AudioVisual |'Vision', 'Audio', Somatossensory, 'AudioVisual', 'Mixed' |
| leftRewardVolume | 2 ul | Amount of water per left reward |
| rightRewardVolume | 2 ul | Amount of water per right reward |
| AutoReward | OFF | Pre-load rewarded spout |
| TrainingMode | OFF | Move spouts to the correct side |
| autoRewardVision | 1 | Fraction of self-performed trials (Vision) |
| autoRewardAudio | 1 | Fraction of self-performed trials (Auditory) |
| autoRewardPiezo | 1 | Fraction of self-performed trials (Somatossensory) |
| autoRewardMixed | 1 | Fraction of self-performed trials (Mixed) |
| LeverSound | true | Play a sound when the mouse touches the handles |
| RegularStim | false | Produce regular stimuli sequences |
| biasSeqLength | 3 | nr of trials on one side after which the oposite side is switched with 50% probability |

Settings for `trial timing` :

| Setting | Default | Description |
|---------|---------|-------------|
| preStimDelay | 1 (s) | time on handle before stimuli presentation |
| StimDuration | 1 (s) | duration of the stimulus |
| happyTime | 0.5 (s) | duration of the last state (gives time to collect reward) |
| varStimDur | 0 (s) | variable stim duration (StimDuration + varStimDur) is the actual stim duration |
| optoDur | 0.5 (s) | duration of the optogenetics stimuli |
| optoRmp | 0.2 (s) | duration of the optogenetics ramp down (optoDur = 0.5 and optoRamp = 0.2 makes a 500ms stimulus that ramps down after 300ms) ??????? |
| minITI | 1 (s) | min inter trial interval (additional) |
| maxITI | 2 (s) | max inter trial interval (additional) |
| ITIlambda | 10 (AU) | bariability between minITI and maxITI. High lambda -> closer to minITI |
| WaitingTime | 1 (s) | minimum waiting time before a response can be made, early licks are ignored |
| TimeToChoose | 3 (s) | how long to wait for choice report |
| TimeToConfirm | 0.5 (s) | ??? |
| Timeout | 3 (s) | timeout to punish wrong responses |
| LeverWait | 10 (s) | time to wait for handle grasp |
| MoveLever | TRUE | move levers or not (set to FALSE during habituation)|
| UseBothLevers | FALSE | Whether both handles need to be touched to initiate trials |
| WaitBeforeLever | 1 (s) | Wait time before handles are moved in after trial onset|

Settings for `stimuli parameters` :

| Setting | Default | Description |
|---------|---------|-------------|
| TargRate  | 10 (Hz) | Rate of the target sequence |
| ProbRight  | 0.5 | Fraction of targets on the right |
| DistFractions  | 0  | Distractor pulses (fraction of the target sequence). Can be a scalar [0-1] or a vector |
| DistProb  | 0  | Probability of presenting a distractor |
| TestModality  | 0  | Modality to be used with discrimination (1=vis, 2=aud, 4=ss). Zero is inactive. Other values are detection only |
| BinSize  | 50 (ms) | Stimuli refractory period (min interval between pulses) |
| StimCoherence  | TRUE | Determines whether multisensory stimuli are correlated | 
| UseNoise  | FALSE | Use noise burst (TRUE) of clicks (FALSE) as auditory stimuli |
| varStimOn  | [0 0.125 0.25] (s) | Variable onset time for stimulus after lever grab in s. This can be a vector of values. Have to be 0 and higher. |
| StimGap  | 0 (s) | Duration of the gap in the middle of stimulus presentation in s; if >0 the stim duration is of stimDuration*2 + stimGap long |
| DecisionGap  | [0.3 1.5] (s) | Range of the interval between the stimulus and the decision period |
| BeepDuration  | 20 (ms) | Beep (auditory) duration |
| StimLoudness  | 0.5 | Strength of auditory stimuli |
| FlashDuration  | 20 (ms) | Flash (visual) duration |
| StimBrightness  | 20  | Brightness of flashes. Multiplier of the base frequency, default is 100Hz (????) |
| BuzzDuration  | 20 (ms) | Buzz (somatossensory) duration |
| BuzzStrength  | 1  | Strength of buzzes |
| ProbAudio  | 0  | Probability of presenting an auditory-only trial (for multimodal) |
| ProbVisual  | 0  | Probability of presenting a visual-only trial (for multimodal) |
| ProbPiezo  | 0  | Probability of presenting a somatossensory-only trial (for multimodal) |
| sRate  | 20000  | Sampling rate of the AnalogOutput module |
| PunishSoundDur  | 0 (s)  | Duration of the white noise punishment sound |
| optoProb  | 0  | Fraction of optogenetics trials |
| optoTimes  | Stimulus/Delay | Part of the trial where optogenetic stimulus should be presented |
| optoRight  | 0.5  | Probability for occurence of an optogenetic stimulus on the right |
| optoBoth  | 1  | Probability for occurence of an optogenetic stimulus on both sides. This comes after determining a single HS target ??? |
| optoPower  | 5  | Fraction of optogenetics stimuli |

Settings for `hardware control and sync` :

| Setting | Default | Description |
|---------|---------|-------------|
| SpoutSpeed | 25 (ms) | Duration of spout movement |
| rMaxSpoutIn | 30 | Right spout inner position (value between 0 and 100) |
| lMaxSpoutIn | 30 | Left spout outer position (value between 0 and 100) |
| spoutOffset | 10 | Distance from inner spout position |
| lOuterLim | 3.5 | Left spout outer position (value between 0 and 100) |
| LeverSpeed | 150 (ms) | Duration of handle movement (ms) |
| LeverIn | 20 | Inner position of the handles |
| LeverOut | 0 | Position of handle out of reach |
| TouchThresh| 5 (SDUs) | Threshold for capacitive touch lines |
| WaitForCam  | false  | Trials wait for a camera trigger to start. |

To check: rInnerLim, lInnerLim, rOuterLim, lOuterLim

Settings for `paths and data copy` :
| Setting | Default | Description |
|---------|---------|-------------|
| widefieldPath | ... | path to widefield data on server |
| serverPath |  ... | path to behavioral data on server |
| videoDrive | C: | path to behavioral data on server |
| bonsaiEXE | ... | path to bonsai.exe  |
| bonsaiParadim | ... | path to the bonsai workflow ('' to skip bonsai)  |
| labcamsAddress | localhost:9999 | address to connect to labcams for video acquisition (leave empty to skip) |
| wavePort | COM18 | COM port of the AnalogOutput Module |

`Plot` settings:
| Variable | Default | Description |
|----------|---------|-------------|
| PerformanceSwitch| Performed | Show performance over all trials or only self-performed trials |
| DoFit| false | Show curve fitting in the performance plot |
| modSelector| Combined | Which data to show in the performance plot |

Operational variables:
| Variable | Default | Description |
|----------|---------|-------------|
| SaveSettings | false | Saves the current settings |
| AdjustSpouts | 0 | Pause for spout adjustment |
| StartTime | ? | Start time of the current session |
| cTrial |  | Number of the current trial |
| runTime |  | Duration of the current session |
| servoPos | [0 0] | position of left and right spout, relative to their inner limit. these values will be changed by anti-bias correction to correct spout position |

## Instalation and build instructions

Clone the repository to Bpod Local/Protocols. If you make changes; create a branch and remember to commit changes regularly.

Build instructions coming here soon.

### Video

There are 2 options for recording video with SpatialSparrow: using [Bonsai](https://bonsai-rx.org/introduction) or using [labcams](https://bitbucket.org/jpcouto/labcams). This readme should show you how to sync the cameras to the BPod (work in progress).

## KiCad design pcb/controller/controller.kicad_pcb

Parts:
5V1: 5V; BarrelJack_Horizontal
9V1: 9V; BarrelJack_Horizontal
12V1: 12V; BarrelJack_Horizontal
C1, C2, C3, C4: 100 uF; C_Rect_L7.2mm_W7.2mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
HandleL-ToMotor1: Screw_Terminal_01x04; TerminalBlock_TE_282825-4_1x04_P5.08mm_Horizontal
HandleR-ToMotor1: Screw_Terminal_01x04; TerminalBlock_TE_282825-4_1x04_P5.08mm_Horizontal
J2: RJ45; RJ45_sparkfun
J5V1, J5V2, J9V1, J12V1, J12V2, J12V3, J12V4: Screw_Terminal_01x02; TerminalBlock_TE_282825-2_1x02_P5.08mm_Horizontal
JP1: gnd jumper; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
MC-LeverL1: Pololu_Breakout_DRV8825; Pololu_Breakout-16_15.2x20.3mm
MC-LeverR1: Pololu_Breakout_DRV8825; Pololu_Breakout-16_15.2x20.3mm
MC-SpoutL1: Pololu_Breakout_DRV8825; Pololu_Breakout-16_15.2x20.3mm
MC-SpoutR1: Pololu_Breakout_DRV8825; Pololu_Breakout-16_15.2x20.3mm
SW5: SW5V; SW_L102021ML04Q
SW9: SW9V; SW_L102021ML04Q
SW12: SW12V; SW_L102021ML04Q
SoundVisionL1: Screw_Terminal_01x06; TerminalBlock_TE_282825-6_1x06_P5.08mm_Horizontal
SoundVisionR1: Screw_Terminal_01x06; TerminalBlock_TE_282825-6_1x06_P5.08mm_Horizontal
SpoutL-ToMotor1: Screw_Terminal_01x04; TerminalBlock_TE_282825-4_1x04_P5.08mm_Horizontal
SpoutR-ToMotor1: Screw_Terminal_01x04; TerminalBlock_TE_282825-4_1x04_P5.08mm_Horizontal
ToHandleL1: Screw_Terminal_01x05; TerminalBlock_TE_282825-5_1x05_P5.08mm_Horizontal
ToHandleR1: Screw_Terminal_01x05; TerminalBlock_TE_282825-5_1x05_P5.08mm_Horizontal
U1: Teensy3.2; Teensy30_31_32_LC
U2: MAX98306
distractor1: Screw_Terminal_01x02; TerminalBlock_TE_282825-2_1x02_P5.08mm_Horizontal
sync_trigger_out1: Screw_Terminal_01x05; TerminalBlock_TE_282825-5_1x05_P5.08mm_Horizontal

Connections:
+5V: J5V1.1, J5V2.1, MC-LeverL1.14 (~SLP), MC-LeverR1.14 (~SLP), MC-SpoutL1.14 (~SLP), MC-SpoutR1.14 (~SLP), SW5.2 (B), U1.33, U2.1
+9V: C1.1, C2.1, C3.1, C4.1, J9V1.1, MC-LeverL1.8 (VMOT), MC-LeverR1.8 (VMOT), MC-SpoutL1.8 (VMOT), MC-SpoutR1.8 (VMOT), SW9.2 (B)
+12V: J12V1.1, J12V2.1, J12V3.1, J12V4.1, SW12.2 (B)
GND: 5V1.2, 12V1.2, J2.1, J5V1.2, J5V2.2, J12V1.2, J12V2.2, J12V3.2, J12V4.2, JP1.2 (B), MC-LeverL1.1 (GND), MC-LeverR1.1 (GND), MC-SpoutL1.1 (GND), MC-SpoutR1.1 (GND), SoundVisionL1.5, SoundVisionR1.5, ToHandleL1.3, ToHandleL1.5, ToHandleR1.3, ToHandleR1.5, U1.1, U1.17, U1.32, U2.2, U2.5, U2.6, distractor1.1
GND1: 9V1.2, C1.2, C2.2, C3.2, C4.2, J9V1.2, JP1.1 (A), MC-LeverL1.7 (GND), MC-LeverR1.7 (GND), MC-SpoutL1.7 (GND), MC-SpoutR1.7 (GND)
unnamed: 5V1.1, SW5.1 (A)
unnamed: 9V1.1, SW9.1 (A)
unnamed: 12V1.1, SW12.1 (A)
unnamed: HandleL-ToMotor1.1, MC-LeverL1.4 (A1)
unnamed: HandleL-ToMotor1.2, MC-LeverL1.3 (A2)
unnamed: HandleL-ToMotor1.3, MC-LeverL1.5 (B1)
unnamed: HandleL-ToMotor1.4, MC-LeverL1.6 (B2)
unnamed: HandleR-ToMotor1.1, MC-LeverR1.4 (A1)
unnamed: HandleR-ToMotor1.2, MC-LeverR1.3 (A2)
unnamed: HandleR-ToMotor1.3, MC-LeverR1.5 (B1)
unnamed: HandleR-ToMotor1.4, MC-LeverR1.6 (B2)
unnamed: J2.2, U2.4
unnamed: J2.3, U2.7
unnamed: J2.4, SoundVisionL1.6
unnamed: J2.5, SoundVisionR1.6
unnamed: J2.6, ToHandleL1.2
unnamed: J2.7, ToHandleR1.2
unnamed: J2.8, distractor1.2
unnamed: MC-LeverL1.15 (STEP), U1.11
unnamed: MC-LeverL1.16 (DIR), U1.12
unnamed: MC-LeverR1.15 (STEP), U1.13
unnamed: MC-LeverR1.16 (DIR), U1.14
unnamed: MC-SpoutL1.3 (A2), SpoutL-ToMotor1.2
unnamed: MC-SpoutL1.4 (A1), SpoutL-ToMotor1.1
unnamed: MC-SpoutL1.5 (B1), SpoutL-ToMotor1.3
unnamed: MC-SpoutL1.6 (B2), SpoutL-ToMotor1.4
unnamed: MC-SpoutL1.15 (STEP), U1.20
unnamed: MC-SpoutL1.16 (DIR), U1.21
unnamed: MC-SpoutR1.3 (A2), SpoutR-ToMotor1.2
unnamed: MC-SpoutR1.4 (A1), SpoutR-ToMotor1.1
unnamed: MC-SpoutR1.5 (B1), SpoutR-ToMotor1.3
unnamed: MC-SpoutR1.6 (B2), SpoutR-ToMotor1.4
unnamed: MC-SpoutR1.15 (STEP), U1.24
unnamed: MC-SpoutR1.16 (DIR), U1.25
unnamed: SoundVisionL1.1, U1.29
unnamed: SoundVisionL1.2, U2.11
unnamed: SoundVisionL1.3, U2.10
unnamed: SoundVisionL1.4, U1.7
unnamed: SoundVisionR1.1, U1.30
unnamed: SoundVisionR1.2, U2.12
unnamed: SoundVisionR1.3, U2.13
unnamed: SoundVisionR1.4, U1.8
unnamed: ToHandleL1.1, U1.22
unnamed: ToHandleL1.4, U1.9
unnamed: ToHandleR1.1, U1.23
unnamed: ToHandleR1.4, U1.10
unnamed: U1.5, sync_trigger_out1.5
unnamed: U1.6, sync_trigger_out1.4
unnamed: U1.26, sync_trigger_out1.1
unnamed: U1.27, sync_trigger_out1.2
unnamed: U1.28, sync_trigger_out1.3

Notes on the sheet:
Stepper motor drivers Handles and Spout motors
Stimuli - analog output connection
Power connectors
INPUT PINS // Inputs for lick sensors LEVERSENSOR_L 15 // touch line for lever touch LEVERSENSOR_R 16 // touch line for lever touch SPOUTSENSOR_L 22 // touch line for left spout SPOUTSENSOR_R 23 // touch line for right spout // Pins for stepper - spouts PIN_SPOUTOUT_L 5 PIN_SPOUTOUT_R 6 PIN_SPOUTST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
4x12 2x5 and 1x9 screw terminals
2- left audio 3- right audio 4- left vision 5- right vision 6- left handle actuator 7- right handle actuator 8- distractor
1- Handle Touch 2- Actuator + 3- Actuator - (GND) 4- Handle Out 5- Handle Zero (GND)
1- Spout Touch 2- Audio + 3- Audio - 4- Spout Out 5- Spout Zero (GND) 6- Visual trigger

Board: 2 copper layers, 151.1 x 123.2 mm, 37 parts (0 on the bottom side), 56 nets.

Other parts of the board:
mount1, mount2: MountingHole_6.5mm_Pad

## KiCad design pcb/led_panel/led_panel.kicad_pcb

Board: 2 copper layers, 160.0 x 40.1 mm, 61 parts (2 on the bottom side), 92 nets.

Parts:
5v: 5V; Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork
BARL1, BARL2: HDSP-4830_2; HDSP-4830
BARR1, BARR2: HDSP-4830_2; HDSP-4830
GND: GND; Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork
LED1, LED2: LED; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
Left teensy: Teensy3.2; Teensy30_31_32_LC
M3_1, M3_2: MountingHole_3.2mm_M3
M4_1, M4_2: MountingHole_4.3mm_M4
RL1, RL2, RL3, RL4, RL5, RL6, RL7, RL8, RL9, RL10, RL11, RL12, RL13, RL14, RL15, RL16, RL17, RL18, RL19, RL20: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
RLED1: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
RR1, RR2, RR3, RR4, RR5, RR6, RR7, RR8, RR9, RR10, RR11, RR12, RR13, RR14, RR15, RR16, RR17, RR18, RR19, RR20: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
RRLED2: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
Right teensy: Teensy3.2; Teensy30_31_32_LC
Tleft: T right; Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork
Tright: T right; Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork
pLED1: LED1; Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork
pLED2: LED2; Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork
terminal: Screw_Terminal_01x10; TerminalBlock_4Ucon_1x10_P3.50mm_Horizontal

Connections:
+5V: 5v.1, Left teensy.33, Right teensy.33, terminal.1
GND: BARL1.11, BARL1.12, BARL1.13, BARL1.14, BARL1.15, BARL1.16, BARL1.17, BARL1.18, BARL1.19, BARL1.20, BARL2.11, BARL2.12, BARL2.13, BARL2.14, BARL2.15, BARL2.16, BARL2.17, BARL2.18, BARL2.19, BARL2.20, BARR1.11, BARR1.12, BARR1.13, BARR1.14, BARR1.15, BARR1.16, BARR1.17, BARR1.18, BARR1.19, BARR1.20, BARR2.11, BARR2.12, BARR2.13, BARR2.14, BARR2.15, BARR2.16, BARR2.17, BARR2.18, BARR2.19, BARR2.20, GND.1, Left teensy.1, RLED1.1, RRLED2.1, Right teensy.1, terminal.2
unnamed: BARL1.1, RL1.2
unnamed: BARL1.2, RL2.2
unnamed: BARL1.3, RL3.2
unnamed: BARL1.4, RL4.2
unnamed: BARL1.5, RL5.2
unnamed: BARL1.6, RL6.2
unnamed: BARL1.7, RL7.2
unnamed: BARL1.8, RL8.2
unnamed: BARL1.9, RL9.2
unnamed: BARL1.10, RL10.2
unnamed: BARL2.1, RL11.2
unnamed: BARL2.2, RL12.2
unnamed: BARL2.3, RL13.2
unnamed: BARL2.4, RL14.2
unnamed: BARL2.5, RL15.2
unnamed: BARL2.6, RL16.2
unnamed: BARL2.7, RL17.2
unnamed: BARL2.8, RL18.2
unnamed: BARL2.9, RL19.2
unnamed: BARL2.10, RL20.2
unnamed: BARR1.1, RR1.2
unnamed: BARR1.2, RR2.2
unnamed: BARR1.3, RR3.2
unnamed: BARR1.4, RR4.2
unnamed: BARR1.5, RR5.2
unnamed: BARR1.6, RR6.2
unnamed: BARR1.7, RR7.2
unnamed: BARR1.8, RR8.2
unnamed: BARR1.9, RR9.2
unnamed: BARR1.10, RR10.2
unnamed: BARR2.1, RR11.2
unnamed: BARR2.2, RR12.2
unnamed: BARR2.3, RR13.2
unnamed: BARR2.4, RR14.2
unnamed: BARR2.5, RR15.2
unnamed: BARR2.6, RR16.2
unnamed: BARR2.7, RR17.2
unnamed: BARR2.8, RR18.2
unnamed: BARR2.9, RR19.2
unnamed: BARR2.10, RR20.2
unnamed: LED1.1, RLED1.2
unnamed: LED1.2, pLED1.1, terminal.5
unnamed: LED2.1, RRLED2.2
unnamed: LED2.2, pLED2.1, terminal.6
unnamed: Right teensy.30, Tright.1, terminal.3
unnamed: Left teensy.30, Tleft.1, terminal.4
unnamed: Right teensy.28, terminal.7
unnamed: Right teensy.29, terminal.8
unnamed: Left teensy.28, terminal.9
unnamed: Left teensy.29, terminal.10
unnamed: Left teensy.2, RL1.1
unnamed: Left teensy.3, RL2.1
unnamed: Left teensy.4, RL3.1
unnamed: Left teensy.5, RL4.1
unnamed: Left teensy.6, RL5.1
unnamed: Left teensy.7, RL6.1
unnamed: Left teensy.8, RL7.1
unnamed: Left teensy.9, RL8.1
unnamed: Left teensy.10, RL9.1
unnamed: Left teensy.11, RL10.1
unnamed: Left teensy.13, RL12.1
unnamed: Left teensy.14, RL13.1
unnamed: Left teensy.20, RL14.1
unnamed: Left teensy.21, RL15.1
unnamed: Left teensy.22, RL16.1
unnamed: Left teensy.23, RL17.1
unnamed: Left teensy.24, RL18.1
unnamed: Left teensy.25, RL19.1
unnamed: Left teensy.26, RL20.1
unnamed: RR1.1, Right teensy.2
unnamed: RR2.1, Right teensy.3
unnamed: RR3.1, Right teensy.4
unnamed: RR4.1, Right teensy.5
unnamed: RR5.1, Right teensy.6
unnamed: RR6.1, Right teensy.7
unnamed: RR7.1, Right teensy.8
unnamed: RR8.1, Right teensy.9
unnamed: RR9.1, Right teensy.10
unnamed: RR10.1, Right teensy.11
unnamed: RR11.1, Right teensy.12
unnamed: RR12.1, Right teensy.13
unnamed: RR13.1, Right teensy.14
unnamed: RR14.1, Right teensy.20
unnamed: RR15.1, Right teensy.21
unnamed: RR16.1, Right teensy.22
unnamed: RR17.1, Right teensy.23
unnamed: RR18.1, Right teensy.24
unnamed: RR19.1, Right teensy.25
unnamed: RR20.1, Right teensy.26
unnamed: Left teensy.12, RL11.1

## KiCad design pcb/motor_controllers/test.kicad_pcb

Board: 2 copper layers, 21 parts (0 on the bottom side), 36 nets.

Parts:
5V1, 9V1: Barrel_Jack; BarrelJack_Horizontal
5VGNDTEST1, 5VTEST1, 9VGNDTEST1, 9VTEST1: TestPoint; TestPoint_Plated_Hole_D5.0mm
C1, C2, C3, C4: 100 uF; C_Rect_L7.2mm_W7.2mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
FromTouch1: Screw_Terminal_01x04; TerminalBlock_TE_282825-4_1x04_P5.08mm_Horizontal
FromZeros1: Screw_Terminal_01x04; TerminalBlock_TE_282825-4_1x04_P5.08mm_Horizontal
LeverL-ToMotor1: Screw_Terminal_01x04; TerminalBlock_TE_282825-4_1x04_P5.08mm_Horizontal
LeverR-ToMotor1: Screw_Terminal_01x04; TerminalBlock_TE_282825-4_1x04_P5.08mm_Horizontal
MC-LeverL1: Pololu_Breakout_DRV8825; Pololu_Breakout-16_15.2x20.3mm
MC-LeverR1: Pololu_Breakout_DRV8825; Pololu_Breakout-16_15.2x20.3mm
MC-SpoutL1: Pololu_Breakout_DRV8825; Pololu_Breakout-16_15.2x20.3mm
MC-SpoutR1: Pololu_Breakout_DRV8825; Pololu_Breakout-16_15.2x20.3mm
SpoutL-ToMotor1: Screw_Terminal_01x04; TerminalBlock_TE_282825-4_1x04_P5.08mm_Horizontal
SpoutR-ToMotor1: Screw_Terminal_01x04; TerminalBlock_TE_282825-4_1x04_P5.08mm_Horizontal
U1: Teensy3.2; Teensy30_31_32_LC

Connections:
unnamed: 5V1.1, 5VTEST1.1, MC-LeverL1.14, MC-LeverR1.14, MC-SpoutL1.14, MC-SpoutR1.14
unnamed: 5V1.2, 5VGNDTEST1.1, MC-LeverL1.1, MC-LeverR1.1, MC-SpoutL1.1, MC-SpoutR1.1
unnamed: 9V1.1, 9VTEST1.1, C1.1, C2.1, C3.1, C4.1, MC-LeverL1.8, MC-LeverR1.8, MC-SpoutL1.8, MC-SpoutR1.8
unnamed: 9V1.2, 9VGNDTEST1.1, C1.2, C2.2, C3.2, C4.2, MC-LeverL1.7, MC-LeverR1.7, MC-SpoutL1.7, MC-SpoutR1.7
unnamed: FromTouch1.1, U1.30
unnamed: FromTouch1.2, U1.29
unnamed: FromTouch1.3, U1.23
unnamed: FromTouch1.4, U1.22
unnamed: FromZeros1.1, U1.10
unnamed: FromZeros1.2, U1.9
unnamed: FromZeros1.3, U1.8
unnamed: FromZeros1.4, U1.7
unnamed: LeverL-ToMotor1.1, MC-LeverL1.4
unnamed: LeverL-ToMotor1.2, MC-LeverL1.3
unnamed: LeverL-ToMotor1.3, MC-LeverL1.5
unnamed: LeverL-ToMotor1.4, MC-LeverL1.6
unnamed: LeverR-ToMotor1.1, MC-LeverR1.4
unnamed: LeverR-ToMotor1.2, MC-LeverR1.3
unnamed: LeverR-ToMotor1.3, MC-LeverR1.5
unnamed: LeverR-ToMotor1.4, MC-LeverR1.6
unnamed: MC-LeverL1.9, U1.11
unnamed: MC-LeverL1.15, U1.12
unnamed: MC-LeverR1.15, U1.13
unnamed: MC-LeverR1.16, U1.14
unnamed: MC-SpoutL1.3, SpoutL-ToMotor1.2
unnamed: MC-SpoutL1.4, SpoutL-ToMotor1.1
unnamed: MC-SpoutL1.5, SpoutL-ToMotor1.3
unnamed: MC-SpoutL1.6, SpoutL-ToMotor1.4
unnamed: MC-SpoutL1.15, U1.20
unnamed: MC-SpoutL1.16, U1.21
unnamed: MC-SpoutR1.3, SpoutR-ToMotor1.2
unnamed: MC-SpoutR1.4, SpoutR-ToMotor1.1
unnamed: MC-SpoutR1.5, SpoutR-ToMotor1.3
unnamed: MC-SpoutR1.6, SpoutR-ToMotor1.4
unnamed: MC-SpoutR1.15, U1.24
unnamed: MC-SpoutR1.16, U1.25

## Commit log

2020-02-15 Analog output works with visual stimuli also. Plot stimuli independently for each modality. Can disable Bonsai (empty path). State machine works with MoveLever disabled. Renamed TouchShaker to use wi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
2020-02-15 Added teensy code for the LEDs and unit tests for when setting up the rigs.
2020-02-15 Moved pins all to the same location in the code and added comments.
2020-02-16 Start labcams with bpod if port is defined and it is not running already.
2020-02-16 labcams start saving on load.
2020-02-18 Added settings to the readme.
2020-02-18 Bold on readme test
2020-02-18 Readme note on video (work in progress)
2020-02-18 Place holder of the description and build instructions
2020-02-20 Updated readme.
2020-02-21 Added pcb lib files
2020-02-21 Added led panel pcb first version.
2020-02-21 Added sym-lib-table to led pcb
2020-02-24 Updated kicad project to be able to load it from multiple computers without conflicts.
2020-02-26 Corrected LED panel pcb (teensy bug...)
2020-03-02 Graph bar test simplified. Step size increase changed. Changed default on guide control drive to C
2020-03-02 Stop video and move spouts before saving to the network.
2020-03-03 message writting to server
2020-03-06 Added labcams default example file.
2020-03-07 Update TouchShaker.ino
    updated touchshaker to include camera trigger on pin 2
2020-03-09 Update TouchShaker.ino
    added pwm for camera timer (pin 3)
2020-03-12 Added button to zero the handles.
2020-03-13 LED panel layout before applying routing.
2020-03-13 Routed LED panel
2020-03-13 Added LED panel gerber files (v2).
2020-03-14 readme for the pcb; how to generate gerber
2020-03-17 Added button to release water on both spouts. Log before starting and after running the state machine.
2020-03-17 Fixed bonsai bug, update video path check
2020-03-18 Added I2C communication
2020-06-12 Added default settings.
2020-06-23 Simple TTL to start trials, simplify sync.
2020-06-26 Trigger recording and send name over the network for widefiend recordings. GUI rescale.
2020-06-26 Place holder to trigger scanimage. Button to trigger widefield.
2020-06-26 Default is triggerWidefield to off. Adjust GUI to fit on small screen.
2020-06-26 Pause before starting widefield experiment
2020-06-27 Start labcams save only after adjusting spouts.
2020-06-27 Added the number of channels to the widefield filename.
2020-06-27 Labcams start saving after spout adjustment like WF.
2020-06-28 WF files are all in the same folder.
2020-07-07 working on PCB for motor controller
2020-07-07 small changes
2020-07-07 Size of window on small screen
2020-07-08 Added analog output RJ45 and audio amplifier symbol.
2020-07-08 Added audio amplifier footprint.
2020-07-08 Added pinout text to kicad
2020-07-08 Pinout added and rj45
2020-07-08 text on screw terminal
2020-07-09 added screw terminal footprints
2020-07-09 added rj45 footprint
2020-07-09 Default path not Simon Behavior. Copy video files to behavior. Organize in folders.
2020-07-10 opened on laptop
2020-07-10 Only copy if ntrials is > 10.
2020-07-10 ran connections and did board layout
2020-07-11 Filled areas on pcb for controller.
2020-07-11 Built controller pcb
2020-07-11 Fixed pin flipped on 12v barrel.
2020-07-11 Added maxServoPos to prevent insane adjustments of the spout.
2020-07-13 Added rules
2020-07-13 Added kicad pcb
2020-07-14 Flipped motor controller for space, added switches
2020-07-14 Netlist update.
2020-07-14 stupid cache file
2020-07-14 Added text for motor wire colors
2020-07-14 Added switch footprint. Updated wiring.
2020-07-14 Removed orphan
2020-07-14 text for handles and spouts
2020-07-14 renamed motor controller. Cleaning up.
2020-07-14 Removed DS_store
2020-07-14 Renamed and cleaned up rescue libs so the project is self-contained.
2020-07-15 Added split LED panel.
2020-07-17 Adde parts for 3d design
2020-07-21 I2C changes for working with the 2P. Works with the new bonsai workflow
2020-07-21 Data from bonsai are also copied,
2020-07-21 StopStim is now TialEnd.
2020-07-21 Printing names stopping the copy.
2020-07-21 Adjust spouts needs to be pressed only once.
2020-07-25 2.2 holes for the set screws on the spout holder
2020-07-25 Handle stepper set screws to 2.2, larger tickness.
2020-07-25 Handle stepper reverted.
2020-07-25 Updated flipped handle holder.
2020-09-14 Controller pcb working version.
2020-11-24 Rolling average on touch sensors. Load cell commented on definition.
2020-11-24 Default target 20.
2020-12-01 Linux support
2020-12-03 Declared spouts in the defaults. Added button to reward a single spout.
2020-12-03 Checked left right to match throughout (needs revision)
2020-12-05 Major! Code refactoring - split SptialSparrow in separate scripts. Removed additional states when parameters change.
2020-12-05 Start labcams on unix.
2020-12-05 Added testing GUI app.
2020-12-08 GUI with app designer can set settings. Plots missing.
2020-12-09 Teensy support for flipping the steppers with compiler defines.
2020-12-11 appdesigner gui update
2020-12-15 Waits for motor movement. Changed communication with the teensy.
2020-12-16 First draft of the new gui.
2020-12-16 Draft performance (functional).
2020-12-17 reset teensy on start.
2020-12-17 teensyreset
2020-12-18 Interrupt for Serial1
2020-12-19 Start and stop Bpod from the GUI. lamps (not ideal).
2020-12-20 Updated performance plots to 10 trials.
2020-12-21 Unrewarded spout stays put on training. Reward button gives water. Move both spouts on HardPunish. Right spout moves on correct trials. Teensy pull required.
2020-12-21 Print capacitance to serial port.
2020-12-22 speed from start
2020-12-24 Updated plots and labcams widefield integration.
2020-12-24 Plot the performed trials on the performance plot.
2020-12-25 labcamsWidefield fix.
2020-12-29 Save path for SpatialSparrow.
2020-12-30 SaveSettings typo fixed. Inter-trial interval drawn from a gamma distribution.
2020-12-31 Fixed typo in vision modality selection.
2021-01-02 Labels on axis of discrimination plots.
2021-01-06 Matlab can set teensy thresholds.
2021-01-06 Threshold sliders go the expected direction now.
2021-01-06 Copy to server adapted to latest changes and serverPath exposed on the gui.
2021-01-06 Button only turns Stop after copy.
2021-01-06 Added switch to disable distractor on one of the each modality.
2021-01-06 Added switch to disable distractor for each modality independently.
2021-01-07 Valve button safe.
2021-01-12 Add server path on start
2021-01-25 flashLED for moving bar.
2021-01-27 Update plot only on initiated trials. Pass the lever speed to the settings.
2021-02-05 Trial queue and stimulus queue. Spout speed limits increased. Changed visualization.
2021-02-09 Remove chan2 output on did not choose
2021-02-09 Send state machine just before running it.
2021-02-12 Fixed when CapaciotiveTouchThresholds don't work.
2021-02-14 Exposed decision delay period.
2021-02-16 Deal with the delay decision gap in the gui
2021-02-19 Don't send touch when the spouts are moving. AutoReward gives reward only after the stimuli. Plot whether the mouse licked or not in auto-reward mode.
2021-02-19 Fix the DisplayTrialData. Prepare trials plot from the start.
2021-02-19 Dont crash on setting the trials if the gui is closed.
2021-02-20 Save file instead of writing a new one.
2021-02-20 Exposed biasSeqLength and added an indicator for assisted trials.
2021-03-04 pausing before giving reward on the gui
2021-06-15 Start and stop scanbox from spatial sparrow
2021-12-01 Example of softCode use.
2021-12-07 init v
2021-12-09 Introduced visual stimuli.
2022-02-11 New Files
2022-06-02 update May
2022-06-06 Version used in the rig prototype.
